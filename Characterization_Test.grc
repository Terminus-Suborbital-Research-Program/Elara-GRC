options:
  parameters:
    generate_options: qt_gui
    id: Basic_Spectrometer
    output_language: python
    title: Basic Spectrometer
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '100'
    step: '0.1'
    stop: '1600'
    value: '1420'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: '4096'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '2411'
    type: float
    vlen: '4096'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: '4096'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '4096'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import time

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="peak_reader",
                  in_sig=[(np.float32, 4096)],
                  out_sig=None
              )

              self.last_print = 0.0

              self.fft_size = 4096
              self.center_freq = 1.42e9
              self.samp_rate = 3e6
              self.decimation = 5
              self.fft_rate = self.samp_rate / self.decimation

          def work(self, input_items, output_items):
              for vec in input_items[0]:
                  peak_index = int(np.argmax(vec))
                  peak_value_db = float(vec[peak_index])

                  bin_width = self.fft_rate / self.fft_size
                  peak_freq = self.center_freq + (peak_index - self.fft_size / 2) * bin_width

                  now = time.time()
                  if now - self.last_print >= 0.2:
                      print(
                          f"Peak bin: {peak_index} | "
                          f"Peak value: {peak_value_db:.3f} dB | "
                          f"Peak freq: {peak_freq:.3f} Hz"
                      )
                      self.last_print = now

              return len(input_items[0])
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '4096'
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.blackmanharris(4096)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e4
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e4
    decim: '5'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0,bias=1"'
    bb_gain0: '20'
    freq0: freq*1e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.1'
    vlen: '4096'
    x_axis_label: '"frequency"'
    x_start: '1419700000'
    x_step: '146.484375'
    y_axis_label: '"Db"'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl,bias=1"'
    bb_gain0: '28'
    freq0: freq*1e6
    gain0: '45'
    gain_mode0: 'False'
    if_gain0: '25'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_real_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [low_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [low_pass_filter_1, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_1, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
